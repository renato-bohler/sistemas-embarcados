<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Modelo_C_asm_IAR7.ewp</path>
  </project>
  <batchBuild/>
</workspace>


