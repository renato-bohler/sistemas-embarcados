<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\blinky\blinky.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lib_EaBaseBoard\Lib_EaBaseBoard.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lib_MCU\Lib_MCU.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\RTOS\RTX\SRC\IAR\RTX_Lib_CM.ewp</path>
    </project>
    <batchBuild />
</workspace>
