# IAR project blinky.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1343 NXP LPC1343
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..; ..\Device\NXP\LPC13xx\Include\; ..\Drivers\include; ..\Lib_EaBaseBoard\inc; ..\Lib_MCU\inc; ..\RTOS\RTX\INC
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: blinky.out
  ILINK.IlinkIcfFile: ..\linker\ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../Lib_EaBaseBoard/Debug/Exe/: Lib_EaBaseBoard.a
    ../Lib_MCU/Debug/Exe/: Lib_MCU.a
    src/: main.c RTX_Conf_CM.c
    ../RTOS/RTX/SRC/IAR/CM3_LE/: RTX_Lib_CM.a
    ../Device/NXP/LPC13xx/Source/IAR/: startup_LPC13xx.s
    ../Device/NXP/LPC13xx/Source/: system_LPC13xx.c
