# IAR project elevador.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\; ..\; ..\inc; ..\driverlib; ..\RTOS\RTX\INC
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..\..
  OBJCOPY.OOCOutputFile: exemplo1.bin
  ILINK.IlinkOutputFile: exemplo1.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../driverlib/ewarm/Exe/: driverlib.a
    src/: main.c RTX_Conf_CM.c startup_tm4c1294ncpdt.c system_tm4c1294ncpdt.c
    ../RTOS/RTX/LIB/IAR/: RTX_CM4.a
