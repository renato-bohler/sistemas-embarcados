<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\driverlib\driverlib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\elevador\elevador.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\RTOS\RTX\SRC\IAR\RTX_Lib_CM.ewp</path>
    </project>
    <batchBuild />
</workspace>
