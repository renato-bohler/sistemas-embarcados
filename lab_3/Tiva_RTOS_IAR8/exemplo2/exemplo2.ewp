# IAR project exemplo2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT
  ICCARM.CCIncludePath2: ..\..\..\; ..\; ..\inc; ..\driverlib; ..\RTOS\RTX\INC
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: exemplo2.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    src/: driverleds.c main.c RTX_Conf_CM.c startup_tm4c1294ncpdt.c system_tm4c1294ncpdt.c
    ../driverlib/ewarm/Exe/: driverlib.a
    ../RTOS/RTX/SRC/IAR/CM4F_LE/: RTX_Lib_CM.a
