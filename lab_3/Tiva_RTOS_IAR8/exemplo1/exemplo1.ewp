# IAR project exemplo1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\; ..\; ..\inc; ..\driverlib; ..\RTOS\RTX\INC
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..\..
  OBJCOPY.OOCOutputFile: exemplo1.bin
  ILINK.IlinkOutputFile: exemplo1.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: driverleds.c driverleds.h main.c RTX_Conf_CM.c startup_tm4c1294ncpdt.c system_tm4c1294ncpdt.c
    ../driverlib/ewarm/Exe/: driverlib.a
    ../RTOS/RTX/LIB/IAR/: RTX_CM4.a
