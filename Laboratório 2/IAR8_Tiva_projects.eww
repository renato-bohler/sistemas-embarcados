<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\driverlib\driverlib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\exemplo1\exemplo1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\exemplo2\exemplo2.ewp</path>
    </project>
    <batchBuild />
</workspace>
